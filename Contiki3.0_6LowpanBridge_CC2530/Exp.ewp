# IAR project Exp.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\_generic\8051.i51
  ICC8051.CCDefines: NETSTACK_CONF_WITH_IPV6=1; SLIP_ARCH_CONF_ENABLE=1
  ICC8051.CCDiagSuppress: Pa050
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: contiki-3.0\core\; contiki-3.0\core\lib\; contiki-3.0\cpu\; contiki-3.0\core\sys\; contiki-3.0\platform\cc2530dk\; contiki-3.0\cpu\cc253x\; contiki-3.0\core\net\; $TOOLKIT_DIR$\inc\dlib\c\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c
  group contiki-border
    contiki-3.0/examples/cc2530dk/border-router/: border-router.c slip-bridge.c
    contiki-3.0/cpu/cc253x/dev/: cc2530-rf.c
    contiki-3.0/core/net/mac/: csma.c frame802154.c framer-802154.c framer.c mac-sequence.c mac.c nullrdc.c
    contiki-3.0/core/net/: netstack.c
    contiki-3.0/core/net/llsec/: nullsec.c
    contiki-3.0/core/net/mac/sicslowmac/: sicslowmac.c
    contiki-3.0/core/net/ipv6/: sicslowpan.c
    contiki-3.0/platform/cc2530dk/dev/: slip-arch.c
    contiki-3.0/core/dev/: slip.c
  group contiki-core
    contiki-3.0/core/sys/: autostart.c ctimer.c etimer.c process.c rtimer.c stimer.c timer.c
    contiki-3.0/cpu/cc253x/dev/: clock.c uart-intr.c uart0.c uart1.c watchdog.c
    contiki-3.0/core/lib/: list.c memb.c random.c
    contiki-3.0/core/net/: packetbuf.c queuebuf.c
    contiki-3.0/cpu/cc253x/: rtimer-arch.c soc.c
  group contiki-rpl
    contiki-3.0/core/net/rpl/: rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-timers.c rpl.c
  group contiki-uip6
    contiki-3.0/core/net/: linkaddr.c nbr-table.c
    contiki-3.0/core/net/ip/: tcpip.c uip-debug.c uip-split.c uiplib.c
    contiki-3.0/core/net/ipv6/: uip-ds6-nbr.c uip-ds6-route.c uip-ds6.c uip-icmp6.c uip-nd6.c uip6.c
